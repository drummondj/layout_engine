VERSION 5.8 ;
BUSBITCHARS "<>" ;
DIVIDERCHAR "/" ;

UNITS
   DATABASE MICRONS 1000 ;
END UNITS

LAYER M1
   TYPE ROUTING ;
   WIDTH 1 ;
   PITCH 2 ;
   DIRECTION HORIZONTAL ;
   CURRENTDEN 1.5 ;
END M1
