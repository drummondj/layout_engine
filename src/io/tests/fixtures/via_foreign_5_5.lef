VERSION 5.5 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

UNITS
   DATABASE MICRONS 1000 ;
END UNITS

LAYER M1
   TYPE ROUTING ;
   DIRECTION HORIZONTAL ;
   WIDTH 0.2 ;
   PITCH 0.4 ;
END M1

LAYER V1
   TYPE CUT ;
END V1

VIA VIA1
   FOREIGN VIA1CELL 0.5 0.5 S ;
   LAYER M1 ;
      RECT -1 -1 1 1 ;
   LAYER V1 ;
      RECT -0.5 -0.5 0.5 0.5 ;
END VIA1

NONDEFAULTRULE WIDE
   LAYER M1
      WIDTH 0.3 ;
      SPACING 0.25 ;
   END M1
   VIA ND_VIA1
      FOREIGN NDCELL 0 0 E ;
      LAYER M1 ;
         RECT -1 -1 1 1 ;
      LAYER V1 ;
         RECT -0.5 -0.5 0.5 0.5 ;
   END ND_VIA1
END WIDE

END LIBRARY
