VERSION 5.3 ;
BUSBITCHARS "<>" ;
DIVIDERCHAR "/" ;
UNITS
   DATABASE MICRONS 1000 ;
END UNITS
END LIBRARY
