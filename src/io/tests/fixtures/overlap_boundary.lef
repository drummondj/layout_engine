VERSION 5.8 ;
BUSBITCHARS "<>" ;
DIVIDERCHAR "/" ;

UNITS
   DATABASE MICRONS 1000 ;
END UNITS

LAYER OVERLAP
   TYPE OVERLAP ;
END OVERLAP

MACRO OVERLAPTEST
   CLASS CORE ;
   ORIGIN 0 0 ;
   SIZE 10 BY 10 ;
   OBS
      LAYER M1 ;
         RECT 0 0 2 2 ;
      LAYER OVERLAP ;
         RECT 1 1 9 9 ;
   END
END OVERLAPTEST
