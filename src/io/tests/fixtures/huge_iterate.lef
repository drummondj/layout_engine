VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

UNITS
   DATABASE MICRONS 1000 ;
END UNITS

LAYER M1
   TYPE ROUTING ;
   DIRECTION HORIZONTAL ;
   PITCH 0.2 ;
   WIDTH 0.1 ;
END M1

MACRO HUGEITER
   CLASS CORE ;
   SIZE 10 BY 10 ;
   OBS
      LAYER M1 ;
         RECT ITERATE 0 0 0.1 0.1 DO 1000 BY 1001 STEP 0.2 0.2 ;
         RECT ITERATE 0 0 0.1 0.1 DO 2 BY 3 STEP 0.2 0.2 ;
   END
END HUGEITER

END LIBRARY
