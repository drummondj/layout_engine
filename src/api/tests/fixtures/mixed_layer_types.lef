VERSION 5.8 ;
BUSBITCHARS "<>" ;
DIVIDERCHAR "/" ;

UNITS
   DATABASE MICRONS 1000 ;
END UNITS

LAYER M1
   TYPE ROUTING ;
   WIDTH 1 ;
   PITCH 2 ;
   DIRECTION HORIZONTAL ;
END M1

LAYER V1
   TYPE CUT ;
   SPACING 0.1 ;
END V1

LAYER OVERLAP
   TYPE OVERLAP ;
END OVERLAP

LAYER SLICE
   TYPE MASTERSLICE ;
END SLICE
