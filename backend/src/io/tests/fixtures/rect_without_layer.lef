VERSION 5.8 ;
BUSBITCHARS "<>" ;
DIVIDERCHAR "/" ;

UNITS
   DATABASE MICRONS 1000 ;
END UNITS

MACRO RECTNOLAYER
   CLASS CORE ;
   SIZE 10 BY 10 ;
   OBS
      RECT 0 0 1 1 ;
   END
END RECTNOLAYER
