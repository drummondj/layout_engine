VERSION 5.8 ;
BUSBITCHARS "<>" ;
DIVIDERCHAR "/" ;

UNITS
   DATABASE MICRONS 1000 ;
END UNITS

MACRO FOREIGNTEST
   CLASS CORE ;
   SIZE 10 BY 10 ;
   FOREIGN F0 ( 1 2 ) N ;
   FOREIGN F1 ( 3 4 ) ;
   FOREIGN F2 ;
   FOREIGN F3 ( 5 6 ) E ;
END FOREIGNTEST
