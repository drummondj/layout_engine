VERSION 5.8 ;
BUSBITCHARS "<>" ;
DIVIDERCHAR "/" ;

UNITS
   DATABASE MICRONS 1000 ;
END UNITS

MACRO DUPTEST
   CLASS CORE ;
   SIZE 10 BY 10 ;
END DUPTEST

MACRO DUPTEST
   CLASS CORE ;
   SIZE 20 BY 20 ;
END DUPTEST
