VERSION 5.8 ;

UNITS
   DATABASE MICRONS 1000 ;
END UNITS

LAYER M1
   TYPE ROUTING ;
   DIRECTION HORIZONTAL ;
   WIDTH 0.2 ;
   PITCH 0.4 ;
END M1

LAYER V1
   TYPE CUT ;
   WIDTH 0.15 ;
END V1

VIA VIA1
   LAYER M1 ;
      RECT -1 -1 1 1 ;
   LAYER V1 ;
      RECT -0.5 -0.5 0.5 0.5 ;
END VIA1

VIARULE VIARULE2
   LAYER M1 ;
      DIRECTION HORIZONTAL ;
      WIDTH 0.1 TO 1.9 ;
   LAYER M1 ;
      DIRECTION VERTICAL ;
      WIDTH 0.1 TO 1.9 ;
   VIA VIA1 ;
END VIARULE2

VIA VIA2
   VIARULE VIARULE2 ;
   CUTSIZE 0.1 0.1 ;
   LAYERS M1 V1 M1 ;
   CUTSPACING 0.1 0.1 ;
   ENCLOSURE 0.05 0.01 0.01 0.05 ;
END VIA2

VIA VIA3
   VIARULE VIARULE2 ;
   CUTSIZE 0.1 0.1 ;
   LAYERS M1 V1 M1 ;
   CUTSPACING 0.1 0.1 ;
   ENCLOSURE 0.05 0.01 0.01 0.05 ;
   ROWCOL 2 3 ;
END VIA3

VIA VIA4
   VIARULE VIARULE2 ;
   CUTSIZE 0.1 0.1 ;
   LAYERS M1 V1 M1 ;
   CUTSPACING 0.1 0.1 ;
   ENCLOSURE 0.05 0.01 0.01 0.05 ;
   ROWCOL 2 3 ;
   ORIGIN 0.02 -0.03 ;
   OFFSET 0.01 0.02 -0.01 -0.02 ;
END VIA4

VIA VIA5
   VIARULE VIARULE2 ;
   CUTSIZE 0.1 0.1 ;
   LAYERS M1 V1 M1 ;
   CUTSPACING 0.1 0.1 ;
   ENCLOSURE 0.05 0.01 0.01 0.05 ;
   ROWCOL 2 3 ;
   PATTERN 11_00_11 ;
END VIA5

VIARULE Via6Array-0 GENERATE
   LAYER M1 ;
      ENCLOSURE 0.02 0.02 ;
   LAYER M1 ;
      ENCLOSURE 0.03 0.03 ;
   LAYER V1 ;
      RECT -0.05 -0.05 0.05 0.05 ;
      SPACING 0.06 BY 0.06 ;
END Via6Array-0
