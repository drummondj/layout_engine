VERSION 5.8 ;
BUSBITCHARS "<>" ;
DIVIDERCHAR "/" ;

MACRO OTHERCELL
   CLASS CORE ;
   SIZE 5 BY 5 ;

   PIN B
      DIRECTION OUTPUT ;
      PORT
         LAYER M1 ;
         RECT 1 1 4 4 ;
      END
   END B
END OTHERCELL
